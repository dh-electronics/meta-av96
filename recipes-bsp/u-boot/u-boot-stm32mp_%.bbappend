FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-u-boot-av96-drivers.patch"
