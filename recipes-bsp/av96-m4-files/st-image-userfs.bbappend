PACKAGE_INSTALL += " \
    av96-m4-files \
    "

