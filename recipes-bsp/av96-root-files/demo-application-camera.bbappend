
do_install_append () {
    rm ${D}${prefix}/local/demo/application/camera/bin/launch_camera_preview.sh
}
