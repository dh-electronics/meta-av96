PACKAGE_INSTALL += " av96-root-files"
