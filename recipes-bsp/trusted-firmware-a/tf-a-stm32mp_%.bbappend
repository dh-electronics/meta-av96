FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += 	"file://0001-tf-a-av96-devicetree.patch \
		 file://0002-stm32mp1-calibration-fix-read-of-HSI-trim-value.patch \
		 file://0003-stm32mp1-calibration-fix-to-find-the-best-trim-value.patch"

