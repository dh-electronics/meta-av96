PROJECTS_LIST_stm32mpcommonmx += 'STM32MP157C-EV1/Applications/OpenAMP/OpenAMP_TTY_echo'
