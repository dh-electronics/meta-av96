FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-tf-a-av96-devicetree.patch"
SRC_URI += "file://0002-hslven_qspi-fix.patch"

